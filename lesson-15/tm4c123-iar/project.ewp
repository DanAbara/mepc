# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\dabar\Documents\modern-embedded-programming-course\lesson-15\tm4c123-iar\project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: bsp.c delay.c delay.h main.c startup_tm4c.c tm4c.h tm4c_cmsis.h
