# Keil uVision project tm4c.uvprojx, settings and files
target Target_1 (ARM-GNU)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tm4c +hex
  group Source
    ./: main.c bsp.c bsp.h startup_tm4c.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
